Commit message: mujoco based rendering

File: assets/orcahand_v1b/urdf/orcahand_v1b.urdf (robot description, URDF)
Before this commit: robot converted_robot, 42 links, 41 joints
Links:
- link tower: geometry visual mesh filename=assets/orcahand_v1b/urdf/converted_tower_mesh.stl
